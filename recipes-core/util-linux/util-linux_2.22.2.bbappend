FILESEXTRAPATHS := "${THISDIR}/files"

# Apply patches
SRC_URI += "file://0001-fdisks-fdiskbsdlabel.h-Add-support-for-microblaze-an.patch"
